# Keil uVision project Project.uvprojx, settings and files
target Project (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1
  c include: ..\USER;..\LIB\inc;..\CMSIS;..\BSP\LED;..\BSP\SysTick;..\BSP\Key;..\BSP\USART;..\BSP\TIMER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c
  group BSP
    ../BSP/USART/: usart.c
    ../BSP/Key/: key.c
    ../BSP/LED/: Led.c
    ../BSP/SysTick/: SysTick.c
    ../BSP/TIMER/: timer.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 4.1.0
